# Keil uVision project iSO-STM32-v5.uvproj, settings and files
target Template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\APP\spi;..\..\APP\delay;..\..\APP\usart;..\..\APP\led;..\..\APP\WS2812B;..\..\APP\ws2811;..\..\APP\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group APP
    ../../APP/spi/: bsp_spi.c
    ../../APP/delay/: delay.c
    ../../APP/usart/: bsp_usart1.c
    ../../APP/led/: bsp_led.c
    ../../APP/WS2812B/: WS2812B.c
    ../../APP/sys/: sys.c
    ../../APP/ws2811/: WS2811.c
software components: CMSIS:CORE 5.0.2
